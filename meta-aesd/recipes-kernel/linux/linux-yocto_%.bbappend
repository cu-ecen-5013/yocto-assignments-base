FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://disable-faulty-builtin.cfg"
